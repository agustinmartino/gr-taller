options:
  parameters:
    author: amartino
    generate_options: qt_gui
    id: test_deinterleave
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: orden
  id: variable
  parameters:
    value: '[171,  68,   4,  74,  41,   7, 110, 117, 174, 102, 158,  17,  59, 141, 159, 112,  46, 129, 182, 131,  50, 101,  64, 138, 170,  77, 125, 181,  92,  27,  65,  86,   8,  73, 123, 144, 198,  87,  20, 62, 108,  28,  94, 151,  13, 113, 165, 127,  39,  89,  11, 152, 120, 186,  56, 109, 164, 114,  53, 155, 107,  99, 154, 169, 153, 40,  79, 128,  32,  29,  47, 193,  81, 195,  97,  93, 140,  23, 35,  33,  98, 132,  54, 142, 126,  66, 191, 134, 133,  42,  76, 161,  61, 177,  71,  19,  36, 162,  58, 175,  45, 147,  48, 146, 80, 160,  44,  60,  12,  96, 196,  49, 116,   3, 183, 187,  88, 10,  16, 115, 197,  26,  57,  25, 143, 122, 137, 199,   9,  38, 24, 173, 105,  31,  18,  91, 172, 121, 111, 104, 192,   2, 180, 119,70,  67, 176, 148,  82,  84, 136, 130, 179,  69,   0,  75, 168,  63,  37,  43,   6,  21, 163, 100,  55,  22,  78,  83, 194, 157, 178, 103,  52,  95, 139, 166, 184,  90,  72,  30, 156,  85, 167,  34,   5, 189,1,  14, 106, 124, 145, 185, 188, 150,  51, 149, 135, 118, 190,  15]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '132000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters:
    vlen: len(orden)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/amartino/GNU_RADIO/Taller_GNU_Radio/grabacion.dat
    repeat: 'False'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
    vlen: len(orden)
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: len(orden)
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: len(orden)
    type: short
  states: {}
- name: taller_deinterleaver_0
  id: taller_deinterleaver
  parameters:
    orden: orden
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: '172'
    display_width: '200'
    fps: '0'
    height: '172'
    type: short
    width: '200'
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_float_to_short_0, '0']
- [blocks_file_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_short_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_to_vector_0, '0', taller_deinterleaver_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', video_sdl_sink_0, '0']
- [taller_deinterleaver_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
